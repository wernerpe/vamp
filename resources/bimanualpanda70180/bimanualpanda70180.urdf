Commit message: rrtc working

File: resources/bimanualpanda70180/bimanualpanda70180.urdf (robot description, URDF)
Before this commit: robot combined_robot, 28 links, 27 joints
Links:
- link panda1::panda_link0: geometry 
- link panda2::panda_link0: geometry 
